# Repository sastles-com/isolation-sphere-solo-xiao

## KiCad design kiban/power-AB-02/boardA/boardA-4layer.kicad_pcb

Parts:
C1: 0.33uF; C0603; LCSC Part C159798
C2, C5, C10, C13, C19, C21: 0.1uF; C0603; LCSC Part C1591
C3, C7, C20: 1uF; C0603; LCSC Part C15849
C4: 0.22uF; C0603; LCSC Part C64705
C6: 2.2uF; C0603; LCSC Part C23630
C8, C9, C15, C16, C17, C18: 22uF; C0805; LCSC Part C45783
C11: 10nF; C0603; LCSC Part C1589
C12, C22, C23, C24: 10uF; C0805; LCSC Part C15850
C14: 47pF; C0603; LCSC Part C1671
J1: MOTHER LEFT; HDR-TH_6P-P2.54-V-M; LCSC Part C492405
J2: MOTHER RIGHT; HDR-TH_6P-P2.54-V-M; LCSC Part C492405
J3: TO BOARD B PWR; HDR-TH_6P-P2.54-V-M; LCSC Part C492405
J4: TO BOARD B SIG; HDR-TH_6P-P2.54-V-M; LCSC Part C492405
J5: VSYS; PinHeader_1x01_P2.00mm_Vertical
J6: GND; PinHeader_1x01_P2.00mm_Vertical
J7: 3V3_MCU; PinHeader_1x01_P2.00mm_Vertical
J8: 3V3_LED; PinHeader_1x01_P2.00mm_Vertical
J9: MCU_EN; PinHeader_1x01_P2.00mm_Vertical
J10: PWR_INT; PinHeader_1x01_P2.00mm_Vertical
J11: MCU_EN; PinHeader_1x01_P2.54mm_Vertical
J12: HALL_WAKE; PinHeader_1x01_P2.54mm_Vertical
J13: 3V3_AON; PinHeader_1x01_P2.54mm_Vertical
J14: VSYS; PinHeader_1x01_P2.54mm_Vertical
J15: LED_EN; PinHeader_1x01_P2.54mm_Vertical
L1: 2.2uH; IND-SMD_L4.0-W4.0; LCSC Part C279948
L2: 2.2uH; IND-SMD_L7.1-W6.5-P5.60; LCSC Part C76855
R1, R6: 100k; R0603; LCSC Part C25803
R2: 5.1k; R0603; LCSC Part C23186
R3: 31.6k; R0603; LCSC Part C25967
R4, R8: 10k; R0603; LCSC Part C25804
R5: 93.1k; R0603; LCSC Part C23266
R7: 20k; R0603; LCSC Part C4184
U1: LTC2954-1; TSOT-23-8_L2.9-W1.6-P0.65-LS2.8-BL; LCSC Part C683782
U2: TPS70933; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; LCSC Part C89347
U3: TPS62933; SOT-583-8_L2.1-W1.2-P0.50-LS1.6-BR; LCSC Part C3200405
U4: TPS566238P; QFN-9_L2.0-W1.5-P0.50-TL_TPS566238PRQFR; LCSC Part C2876603

Connections:
3V3_AON: C6.1, J1.6, J13.1, U2.5 (OUT)
3V3_LED: C14.1, C15.1, C16.1, C17.1, C18.1, J1.1, J2.1, J8.1, L2.2, R5.1
3V3_MCU: C8.1, C9.1, J1.3, J7.1, L1.2, R1.1, R3.1, R8.1
CHG_INT: J4.4, R8.2
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.2, C12.2, C13.2, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C22.2, C23.2, C24.2, J1.2, J2.2, J2.3, J3.4, J3.5, J3.6, J4.2, J4.6, J6.1, R4.2, R6.2, R7.2, U1.4 (GND), U2.2 (GND), U3.1 (RT), U3.4 (GND), U4.4 (PGND)
HALL_WAKE: J2.4, J12.1, R2.1
I2C_SCL: J1.5, J4.3
I2C_SDA: J1.4, J4.1
LED_EN: J2.6, J15.1, R6.1, U4.3 (EN)
L_BST: C19.1, U4.7 (BST)
L_FB: C14.2, R5.2, R7.1, U4.2 (FB)
L_PG: U4.9 (PG)
L_SW: C19.2, L2.1, U4.8 (SW)
L_VCC: C20.1, U4.1 (VCC)
MCU_EN: J9.1, J11.1, U1.6 (EN/~EN), U3.2 (EN)
M_BST: C10.1, U3.6 (BST)
M_FB: R3.2, R4.1, U3.8 (FB)
M_SS: C11.1, U3.7 (SS)
M_SW: C10.2, L1.1, U3.5 (SW)
ONT: C1.2, U1.3 (ONT)
PB_F: C2.1, R2.2, U1.2 (~PB)
PDT: C3.1, C4.1, U1.7 (PDT)
PWR_INT: J10.1, U1.5 (~INT)
PWR_KILL: J2.5, R1.2, U1.8 (~KILL)
VSYS: C5.1, C7.1, C12.1, C13.1, C21.1, C22.1, C23.1, C24.1, J3.1, J3.2, J3.3, J5.1, J14.1, U1.1 (VIN), U2.1 (IN), U2.3 (EN), U3.3 (VIN), U4.5 (VIN), U4.6 (VIN)

Notes on the sheet:
3.3 V = 0.8 x (1 + 31.6k / 10k)
プルアップ（3V3_MCU、基板A に集約）
LED 用 3.3 V 降圧 U4 TPS566238P（6 A、LED_EN で ON）
RT = GND：1.2 MHz
LED_EN：GND へ 100k（MCU 起動前は OFF）
I2C 4.7k、CHG_INT 10k
J3 / J4 は基板B の J_AB1 / J_AB2 と同じピン配置
MCU 用 3.3 V 降圧 U3 TPS62933（1.2 MHz、LTC2954 が EN を制御）
PWR_KILL の 100k は POWER ページ
HALL_WAKE：北極 DRV5032FC（磁石で L）
J1：左（3V3_LED_L / GND_L / 3V3_MCU / SDA / SCL / 3V3_AON）
基板B 接続（ピンヘッダ 1x6 × 2）
（WS2812C の下限 3.3 V に余裕。実測後に R5 を調整）
PWR_INT はテストパッドへ（任意）
L_PG：テストパッドへ（任意）
3V3_AON：北極の DRV5032FC だけに給電（待機電流 1.4 uA）
J2：右（3V3_LED_R / GND_R / GND_SYS / HALL_WAKE / PWR_KILL / LED_EN）
強制 OFF 約 7.9 s（1 + 0.22 uF）
出力 = 0.6 x (1 + 93.1k / 20k) = 3.39 V
mother-ring 接続（1x6 × 2、左右の張り出し）
電源 ON/OFF U1 LTC2954-1（磁石の長押し）
KILL は 3V3_MCU へプルアップ
常時オン 3.3 V U2 TPS70933
EN（MCU_EN）は U3 の EN に直結（外付けプルアップなし。U3 の内部プルアップ 0.7 uA）
テストパッド（直径 1.0 mm、部品なし。コネクタのピンで測れないネットだけ）
ON 長押し 約 2.15 s

Board: 4 copper layers, 45.7 x 40.0 mm, 53 parts (49 on the bottom side), 24 nets.

## KiCad design kiban/power-AB-02/boardB-reverse/boardB-reverse-2layer-trial.kicad_pcb

Parts:
C1, C2, C4, C5, C6, C12, C13, C14, C15, C16, C17, C18: 10uF; C0805; LCSC Part C15850
C3, C7, C19, C20, C21, C22, C23, C25, C27, C28, C29: 0.1uF; C0603; LCSC Part C1591
C8: 4.7uF; C0603; LCSC Part C19666
C9: 1nF; C0603; LCSC Part C1588
C10, C11: 47nF; C0603; LCSC Part C1622
C24: 1uF; C0603; LCSC Part C15849
C26: 2.2uF; C0603; LCSC Part C23630
D1: SMF15A; SOD-123FL_L2.8-W1.8-LS3.6-RD; LCSC Part C2900732
D2: LED; LED-SMD_L1.6-W0.8-R-RD; LCSC Part C2286
F2: Polyfuse 5A; FUSE-SMD_L8.0-W5.4; LCSC Part C108585
J1: J_CHG; HDR-TH_2P-P2.54-V-M; LCSC Part C492401
J2: AB1; HDR-TH_6P-P2.54-V-M; LCSC Part C492405
J3: AB2; HDR-TH_6P-P2.54-V-M; LCSC Part C492405
J4: J_CELL1; HDR-TH_2P-P2.54-V-M; LCSC Part C492401
J5: J_CELL2; HDR-TH_2P-P2.54-V-M; LCSC Part C492401
J10: PACK_P; PinHeader_1x01_P2.00mm_Vertical
J11: BAT_F; PinHeader_1x01_P2.00mm_Vertical
J12: REGN; PinHeader_1x01_P2.00mm_Vertical
J13: TS; PinHeader_1x01_P2.00mm_Vertical
J14: VSYS; PinHeader_1x01_P2.00mm_Vertical
L2: 1uH; IND-SMD_L7.1-W6.5-P5.60; LCSC Part C87572
Q2: FS8205A_C908265; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; MPN FS8205A; LCSC Part C908265
R1: 100kΩ; R0603; LCSC Part C25803
R2: 127kΩ; R0603; LCSC Part C22869
R3: 6.04kΩ; R0603; LCSC Part C25977
R4: 5.23kΩ; R0603; LCSC Part C23068
R5: 30.1kΩ; R0603; LCSC Part C23000
R6, R13: NCP18XH103F03RB; R0603; MPN NCP18XH103F03RB; LCSC Part C13564
R7: 10kΩ; R0603; LCSC Part C25804
R8: 2.2kΩ; R0603; LCSC Part C4190
R9, R12, R19, R20: 100Ω; R0603; LCSC Part C22775
R10: 10Ω; R0603; LCSC Part C22859
R11: 5.1Ω; R0603; LCSC Part C25197
R14, R15: 5.1kΩ; R0603; LCSC Part C23186
R16, R17: 10MΩ; R0603; LCSC Part C7250
R18: LR1206-21R002F4; R1206; MPN LR1206-21R002F4; LCSC Part C154630
U1: BQ28Z620DRZR; SON-12_L4.0-W2.5-P0.40-TL-EP; MPN BQ28Z620DRZR; LCSC Part C20345237
U3: BQ25792RQMR; QFN-29_L4.0-W4.0-P0.40-TL-BQ25792RQMR; MPN BQ25792RQMR; LCSC Part C2862876

Connections:
BATP: R9.2, U3.18 (BATP)
BAT_F: C20.2, F2.2, J11.1, Q2.1 (S1), R16.1; also elsewhere on the board
BAT_MID: J4.2, J5.1, R12.2
BAT_N: C25.2, C26.2, C27.2, C28.2, J4.1, R13.2, R18.2, R20.2, U1.1 (VSS), U1.13 (EP)
BAT_TOP: F2.1, J5.2, R11.1
BTST1: C10.1, U3.4 (BTST1)
BTST2: C11.1, U3.19 (BTST2)
CHG_G: Q2.6 (G1), R14.1, R16.2
CHG_INT: J3.4, U3.21 (~INT)
CHG_O: R14.2, U1.9 (CHG)
DSG_G: Q2.4 (G2), R15.1, R17.2
DSG_O: R15.2, U1.7 (DSG)
FET_D: Q2.2 (D1/D2), Q2.5 (D1/D2)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C23.1, D1.2 (A2), J1.1, J2.4, J2.5, J2.6, J3.2, J3.6, R1.2, R3.2, R5.2, R6.2, R7.2, R18.1, R19.2, U3.10 (ACDRV2), U3.11 (ACDRV1), U3.27 (GND)
I2C_SCL: J3.3, U1.5 (SCL), U3.14 (SCL)
I2C_SDA: J3.1, U1.6 (SDA), U3.15 (SDA)
ILIM_HIZ: R1.1, R2.2, U3.17 (ILIM_HIZ)
unnamed: C20.1, C21.2
unnamed: C22.1, C23.2
unnamed: D2.1 (A), R8.2
unnamed: D2.2 (K), U3.1 (STAT)
unnamed: R7.1, U3.13 (~CE)
PACK_P: C12.2, C13.2, C21.1, C22.2, J10.1, Q2.3 (S2), R9.1, R10.1, R17.1, U3.22 (BAT), U3.23 (BAT); also elsewhere on the board
PACK_S: R10.2, U1.8 (PACK)
PBI: C26.1, U1.10 (PBI)
PMID: C4.2, C5.2, C6.2, C7.2, U3.29 (PMID)
PROG: R3.1, U3.20 (PROG)
REGN: C8.2, J12.1, R2.1, R4.1, R8.1, U3.5 (REGN)
SDRV: C9.2, U3.24 (SDRV)
SRN_F: C27.1, C29.1, R19.1, U1.2 (SRN)
SRP_F: C28.1, C29.2, R20.1, U1.3 (SRP)
SW1: C10.2, L2.1, U3.28 (SW1)
SW2: C11.2, L2.2, U3.26 (SW2)
TS: J13.1, R4.2, R5.1, R6.1, U3.16 (TS)
TS1: R13.1, U1.4 (TS1)
VBUS: C1.2, C2.2, C3.2, D1.1 (A1), J1.2, U3.2 (VBUS), U3.3 (VBUS), U3.8 (VAC2), U3.9 (VAC1)
VC1_F: C24.2, C25.1, R12.1, U1.12 (VC1)
VC2_F: C24.1, R11.2, U1.11 (VC2)
VSYS: C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, J2.1, J2.2, J2.3, J14.1, U3.25 (SYS)

Notes on the sheet:
GND（PACK−）側 ← RSNS 2mΩ → BAT_N（セル−）側
残量計・保護 U1 BQ28Z620
BATP：電池の＋を検出
充電 IC U3 BQ25792
SRN / SRP はシャントの両端のパッドから直接取る
主電流路
A-B コネクタ
充電入力（線をはんだ付けする 2 穴、5〜12 V）
テストパッド（直径 1.0 mm、部品なし。コネクタのピンで測れないネットだけ）
電流シャント（ケルビン接続）
J_CHG：PH 2P の線をはんだ付け（部品なし）

Parts:
C1, C2, C4, C5, C6, C12, C13, C14, C15, C16, C17, C18: 10uF; C0805; LCSC Part C15850
C3, C7, C19, C20, C21, C22, C23, C25, C27, C28, C29: 0.1uF; C0603; LCSC Part C1591
C8: 4.7uF; C0603; LCSC Part C19666
C9: 1nF; C0603; LCSC Part C1588
C10, C11: 47nF; C0603; LCSC Part C1622
C24: 1uF; C0603; LCSC Part C15849
C26: 2.2uF; C0603; LCSC Part C23630
D1: SMF15A; SOD-123FL_L2.8-W1.8-LS3.6-RD; LCSC Part C2900732
D2: LED; LED-SMD_L1.6-W0.8-R-RD; LCSC Part C2286
F2: Polyfuse 5A; FUSE-SMD_L8.0-W5.4; LCSC Part C108585
J1: J_CHG; HDR-TH_2P-P2.54-V-M; LCSC Part C492401
J2: AB1; HDR-TH_6P-P2.54-V-M; LCSC Part C492405
J3: AB2; HDR-TH_6P-P2.54-V-M; LCSC Part C492405
J4: J_CELL1; HDR-TH_2P-P2.54-V-M; LCSC Part C492401
J5: J_CELL2; HDR-TH_2P-P2.54-V-M; LCSC Part C492401
J10: PACK_P; PinHeader_1x01_P2.00mm_Vertical
J11: BAT_F; PinHeader_1x01_P2.00mm_Vertical
J12: REGN; PinHeader_1x01_P2.00mm_Vertical
J13: TS; PinHeader_1x01_P2.00mm_Vertical
J14: VSYS; PinHeader_1x01_P2.00mm_Vertical
L2: 1uH; IND-SMD_L7.1-W6.5-P5.60; LCSC Part C87572
Q2: FS8205A_C908265; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; MPN FS8205A; LCSC Part C908265
R1: 100kΩ; R0603; LCSC Part C25803
R2: 127kΩ; R0603; LCSC Part C22869
R3: 6.04kΩ; R0603; LCSC Part C25977
R4: 5.23kΩ; R0603; LCSC Part C23068
R5: 30.1kΩ; R0603; LCSC Part C23000
R6, R13: NCP18XH103F03RB; R0603; MPN NCP18XH103F03RB; LCSC Part C13564
R7: 10kΩ; R0603; LCSC Part C25804
R8: 2.2kΩ; R0603; LCSC Part C4190
R9, R12, R19, R20: 100Ω; R0603; LCSC Part C22775
R10: 10Ω; R0603; LCSC Part C22859
R11: 5.1Ω; R0603; LCSC Part C25197
R14, R15: 5.1kΩ; R0603; LCSC Part C23186
R16, R17: 10MΩ; R0603; LCSC Part C7250
R18: LR1206-21R002F4; R1206; MPN LR1206-21R002F4; LCSC Part C154630
R21: 8.2kΩ; R0603; LCSC Part C25981
SW1: TS-1187A-B-A-B; SW-SMD_4P-L5.1-W5.1-P3.70-LS6.5-TL_H1.5; LCSC Part C318884
U1: BQ28Z620DRZR; SON-12_L4.0-W2.5-P0.40-TL-EP; MPN BQ28Z620DRZR; LCSC Part C20345237
U3: BQ25792RQMR; QFN-29_L4.0-W4.0-P0.40-TL-BQ25792RQMR; MPN BQ25792RQMR; LCSC Part C2862876

Connections:
BATP: R9.2, U3.18 (BATP)
BAT_F: C20.2, F2.2, J11.1, Q2.1 (S1), R16.1, R21.1
BAT_MID: J4.2, J5.1, R12.2
BAT_N: C25.2, C26.2, C27.2, C28.2, J4.1, R13.2, R18.2, R20.2, U1.1 (VSS), U1.13 (EP)
BAT_TOP: F2.1, J5.2, R11.1
BTST1: C10.1, U3.4 (BTST1)
BTST2: C11.1, U3.19 (BTST2)
CHG_G: Q2.6 (G1), R14.1, R16.2
CHG_INT: J3.4, U3.21 (~INT)
CHG_O: R14.2, U1.9 (CHG)
DSG_G: Q2.4 (G2), R15.1, R17.2
DSG_O: R15.2, U1.7 (DSG)
FET_D: Q2.2 (D1/D2), Q2.5 (D1/D2)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C23.1, D1.2 (A2), J1.1, J2.4, J2.5, J2.6, J3.2, J3.6, R1.2, R3.2, R5.2, R6.2, R7.2, R18.1, R19.2, U3.10 (ACDRV2), U3.11 (ACDRV1), U3.27 (GND)
I2C_SCL: J3.3, U1.5 (SCL), U3.14 (SCL)
I2C_SDA: J3.1, U1.6 (SDA), U3.15 (SDA)
ILIM_HIZ: R1.1, R2.2, U3.17 (ILIM_HIZ)
unnamed: C20.1, C21.2
unnamed: C22.1, C23.2
unnamed: D2.1 (A), R8.2
unnamed: D2.2 (K), U3.1 (STAT)
unnamed: R21.2, SW1.1 (A)
unnamed: R7.1, U3.13 (~CE)
PACK_P: C12.2, C13.2, C21.1, C22.2, J10.1, Q2.3 (S2), R9.1, R10.1, R17.1, SW1.4 (D), U3.22 (BAT), U3.23 (BAT)
PACK_S: R10.2, U1.8 (PACK)
PBI: C26.1, U1.10 (PBI)
PMID: C4.2, C5.2, C6.2, C7.2, U3.29 (PMID)
PROG: R3.1, U3.20 (PROG)
REGN: C8.2, J12.1, R2.1, R4.1, R8.1, U3.5 (REGN)
SDRV: C9.2, U3.24 (SDRV)
SRN_F: C27.1, C29.1, R19.1, U1.2 (SRN)
SRP_F: C28.1, C29.2, R20.1, U1.3 (SRP)
SW1: C10.2, L2.1, U3.28 (SW1)
SW2: C11.2, L2.2, U3.26 (SW2)
TS: J13.1, R4.2, R5.1, R6.1, U3.16 (TS)
TS1: R13.1, U1.4 (TS1)
VBUS: C1.2, C2.2, C3.2, D1.1 (A1), J1.2, U3.2 (VBUS), U3.3 (VBUS), U3.8 (VAC2), U3.9 (VAC1)
VC1_F: C24.2, C25.1, R12.1, U1.12 (VC1)
VC2_F: C24.1, R11.2, U1.11 (VC2)
VSYS: C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, J2.1, J2.2, J2.3, J14.1, U3.25 (SYS)

Notes on the sheet:
GND（PACK−）側 ← RSNS 2mΩ → BAT_N（セル−）側
残量計・保護 U1 BQ28Z620
BATP：電池の＋を検出
充電 IC U3 BQ25792
SRN / SRP はシャントの両端のパッドから直接取る
主電流路
A-B コネクタ
充電入力（線をはんだ付けする 2 穴、5〜12 V）
テストパッド（直径 1.0 mm、部品なし。コネクタのピンで測れないネットだけ）
電流シャント（ケルビン接続）
J_CHG：PH 2P の線をはんだ付け（部品なし）
残量計を起こすボタン（電池をつないだ直後に 1 回押す）
BQ28Z620 は PACK が 2.05〜2.45 V を超えるまで SHUTDOWN のまま。PACK は Q2 の先なので、電池だけでは起きない。
押すと BAT_F → 8.2 kΩ → PACK_P に電圧が掛かり、残量計が起きる（充電入力を入れても起きる）。
SW1 は対角の 1 番と 4 番を使う（1-2、3-4 は内部でつながる）。常時つなぐ抵抗にはしない（保護 FET の迂回路になる）。

Board: 2 copper layers, 40.0 x 40.0 mm, 66 parts (66 on the bottom side), 39 nets.
